# IAR project HITSIC_MK66F18.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FX1M0xxx18 NXP MK66FX1M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: DEBUG; CPU_MK66FX1M0VLQ18; ARM_MATH_CM4; HITSIC_MK66F18; SERIAL_PORT_TYPE_UART=1; SERIAL_PORT_TYPE_SWO=0
  ICCARM.CCDiagSuppress: pa082,pe223,pe1665
  ICCARM.CCIncludePath2: ..\..\..\CMSIS_5.6.0\Core\Include; ..\..\..\CMSIS_5.6.0\DSP\Include; ..\..\..\CMSIS_5.6.0\NN\Include; ..\..\..\devices\MK66F18\drivers; ..\..\..\devices\MK66F18\utilities\str; ..\..\..\devices\MK66F18\utilities\debug_console; ..\..\..\devices\MK66F18\utilities; ..\..\..\devices\MK66F18; ..\..\..\components\uart; ..\..\..\components\lists; ..\..\..\components\serial_manager; ..\..\..\HITSIC\d_mk66f18\extlib_port\cm_backtrace\cmb_1.3.0; ..\..\..\HITSIC\d_mk66f18; ..\..\..\HITSIC\utilities\extlib\cm_backtrace\cmb_1.3.0; ..\..\..\HITSIC\utilities\lib; ..\..\..\HITSIC\utilities\rte; ..\..\..\HITSIC\utilities\drv; ..\..\..\HITSIC\utilities\sys; ..\..\..\HITSIC\utilities\app; ..\..\..\HITSIC\utilities; ..\board; ..\main
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HITSIC_MK66F18.srec
  ILINK.IlinkOutputFile: HITSIC_MK66F18.out
  ILINK.IlinkIcfFile: MK66FX1M0xxx18_flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\CMSIS_5.6.0\DSP\Lib\IAR\iar_cortexM4lf_math.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group board
    ../board/: board.c board.h clock_config.c clock_config.h peripherals.c peripherals.h pin_mux.c pin_mux.h
  group chip/cmsis_5.6.0/core
    ../../../CMSIS_5.6.0/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_cm4.h mpu_armv7.h tz_context.h
  group chip/cmsis_5.6.0/dsp
    ../../../CMSIS_5.6.0/DSP/Include/: arm_common_tables.h arm_const_structs.h arm_math.h
  group chip/cmsis_5.6.0/nn
    ../../../CMSIS_5.6.0/NN/Include/: arm_nn_tables.h arm_nnfunctions.h arm_nnsupportfunctions.h
  group chip/mk66
    ../../../devices/MK66F18/: fsl_device_registers.h MK66F18.h MK66F18_features.h system_MK66F18.c system_MK66F18.h
    ../../../devices/MK66F18/iar/: startup_MK66F18.s
  group chip/mk66/components/lists
    ../../../components/lists/: generic_list.c generic_list.h
  group chip/mk66/components/serial_manager
    ../../../components/serial_manager/: serial_manager.c serial_manager.h serial_port_internal.h serial_port_swo.c serial_port_swo.h serial_port_uart.c serial_port_uart.h
  group chip/mk66/components/uart
    ../../../components/uart/: uart.h uart_adapter.c
  group chip/mk66/drivers
    ../../../devices/MK66F18/drivers/: fsl_adc16.c fsl_adc16.h fsl_cache.c fsl_cache.h fsl_clock.c fsl_clock.h fsl_cmp.c fsl_cmp.h fsl_cmt.c fsl_cmt.h fsl_common.c fsl_common.h fsl_crc.c fsl_crc.h fsl_dac.c fsl_dac.h fsl_dmamux.c fsl_dmamux.h fsl_dspi.c fsl_dspi.h fsl_dspi_edma.c fsl_dspi_edma.h fsl_edma.c fsl_edma.h fsl_enet.c fsl_enet.h fsl_ewm.c fsl_ewm.h fsl_flash.h fsl_flexbus.c fsl_flexbus.h fsl_flexcan.c fsl_flexcan.h fsl_ftfx_adapter.h fsl_ftfx_cache.c fsl_ftfx_cache.h fsl_ftfx_controller.c fsl_ftfx_controller.h fsl_ftfx_features.h fsl_ftfx_flash.c fsl_ftfx_flash.h fsl_ftfx_flexnvm.c fsl_ftfx_flexnvm.h fsl_ftfx_utilities.h fsl_ftm.c fsl_ftm.h fsl_gpio.c fsl_gpio.h fsl_i2c.c fsl_i2c.h fsl_i2c_edma.c fsl_i2c_edma.h fsl_llwu.c fsl_llwu.h fsl_lmem_cache.c fsl_lmem_cache.h fsl_lptmr.c fsl_lptmr.h fsl_lpuart.c fsl_lpuart.h fsl_lpuart_edma.c fsl_lpuart_edma.h fsl_pdb.c fsl_pdb.h fsl_pit.c fsl_pit.h fsl_pmc.c fsl_pmc.h fsl_port.h fsl_rcm.c fsl_rcm.h fsl_rnga.c fsl_rnga.h fsl_rtc.c fsl_rtc.h fsl_sai.c fsl_sai.h fsl_sai_edma.c fsl_sai_edma.h fsl_sdhc.c fsl_sdhc.h fsl_sdramc.c fsl_sdramc.h fsl_sim.c fsl_sim.h fsl_smc.c fsl_smc.h fsl_sysmpu.c fsl_sysmpu.h fsl_tpm.c fsl_tpm.h fsl_tsi_v4.c fsl_tsi_v4.h fsl_uart.c fsl_uart.h fsl_uart_edma.c fsl_uart_edma.h fsl_vref.c fsl_vref.h fsl_wdog.c fsl_wdog.h
  group chip/mk66/utilities
    ../../../devices/MK66F18/utilities/: fsl_assert.c fsl_notifier.c fsl_notifier.h fsl_shell.c fsl_shell.h
    ../../../devices/MK66F18/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h fsl_debug_console_conf.h
    ../../../devices/MK66F18/utilities/str/: fsl_str.c fsl_str.h
  group hitsic/d_mk66f18
    ../../../HITSIC/d_mk66f18/: hitsic_common.c hitsic_common.h hitsic_def.h hitsic_hal.c hitsic_hal.h inc_fsl_mk66f18.h
  group hitsic/d_mk66f18/extlib_port/cm_backtrace_1.3.0
    ../../../HITSIC/d_mk66f18/extlib_port/cm_backtrace/cmb_1.3.0/: cmb_cfg.h cmb_def.h
  group hitsic/utilities/app
    ../../../HITSIC/utilities/app/: app_menu.c app_menu.h
  group hitsic/utilities/drv
    ../../../HITSIC/utilities/drv/: drv_button.c drv_button.h drv_disp_ssd1306.c drv_disp_ssd1306.h drv_ftfx_flash.c drv_ftfx_flash.h drv_imu_invensense.c drv_imu_invensense.h
  group hitsic/utilities/extlib/cm_backtrace_1.3.0
    ../../../HITSIC/utilities/extlib/cm_backtrace/cmb_1.3.0/: cm_backtrace.c cm_backtrace.h cmb_fault.S
  group hitsic/utilities/lib
    ../../../HITSIC/utilities/lib/: lib_list.c lib_list.h
  group hitsic/utilities/rte
    ../../../HITSIC/utilities/rte/: rte_i2c.c rte_i2c.h rte_softi2c.c rte_softi2c.h rte_spi.c rte_spi.h rte_uart.c rte_uart.h
  group hitsic/utilities/sys
    ../../../HITSIC/utilities/sys/: sys_extint.c sys_extint.h sys_pitmgr.c sys_pitmgr.h sys_uartmgr.c sys_uartmgr.h
  group main
    ../main/: inc_generic.h inc_stdlib.h main.c stdafx.c stdafx.h
